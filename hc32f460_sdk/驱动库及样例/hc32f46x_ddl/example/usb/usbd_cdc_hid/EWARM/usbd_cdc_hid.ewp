# IAR project usbd_cdc_hid.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\usb_lib\ctl_drv; ..\..\..\..\usb_lib\device_core; ..\..\..\..\usb_lib\device_class\cdc_vcp; ..\..\..\..\usb_lib\device_class\hid_custom; ..\..\..\..\usb_lib\device_class\hid_cdc_wrapper
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_cdc_hid.srec
  ILINK.IlinkOutputFile: usbd_cdc_hid.out
  ILINK.IlinkIcfFile: hc32f46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\usb_lib\ctl_drv; ..\..\..\..\usb_lib\device_core; ..\..\..\..\usb_lib\device_class\cdc_vcp; ..\..\..\..\usb_lib\device_class\hid_custom; ..\..\..\..\usb_lib\device_class\hid_cdc_wrapper; ..\..\..\..\utility
  group common
    ../../../../mcu/common/: system_hc32f46x.c
    ./: startup_hc32f46x.s
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_usart.c
  group usb_lib/ctl_drv
    ../../../../usb_lib/ctl_drv/: usb_core.c usb_otg.c usb_dcd.c usb_dcd_int.c
  group usb_lib/device_core
    ../../../../usb_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb_lib/device_class
    ../../../../usb_lib/device_class/cdc_vcp/: usbd_cdc_vcp_core.c
    ../../../../usb_lib/device_class/hid_custom/: usbd_hid_custom_core.c
    ../../../../usb_lib/device_class/hid_cdc_wrapper/: usbd_hid_cdc_wrapper.c
  group source
    ../source/: main.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usb_bsp_template.c
