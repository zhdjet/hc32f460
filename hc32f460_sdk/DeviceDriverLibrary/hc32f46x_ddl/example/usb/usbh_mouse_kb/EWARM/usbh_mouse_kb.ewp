# IAR project usbh_mouse_kb.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\usb_lib\ctl_drv; ..\..\..\..\usb_lib\host_core; ..\..\..\..\usb_lib\host_class\hid
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_mouse_kb.srec
  ILINK.IlinkOutputFile: usbh_mouse_kb.out
  ILINK.IlinkIcfFile: hc32f46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\usb_lib\ctl_drv; ..\..\..\..\usb_lib\host_core; ..\..\..\..\usb_lib\host_class\hid; ..\..\..\..\utility
  group common
    ../../../../mcu/common/: system_hc32f46x.c
    ./: startup_hc32f46x.s
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c
  group usb_lib/ctl_drv
    ../../../../usb_lib/ctl_drv/: usb_core.c usb_otg.c usb_hcd.c usb_hcd_int.c
  group usb_lib/host_core
    ../../../../usb_lib/host_core/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group usb_lib/host_class
    ../../../../usb_lib/host_class/hid/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group source
    ../source/: main.c usbh_usr.c usbh_usr_print.c usb_bsp_template.c
